unset MENDER_MACHINE[export]
BB_HASHBASE_WHITELIST_remove = "MENDER_MACHINE"

#MENDER_MACHINE = "${MACHINE}"
